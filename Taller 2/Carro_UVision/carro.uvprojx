# Keil uVision project carro.uvprojx, settings and files
target Target_1 (ARM-ADS)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20020000,0x0005C000) IROM(0x08000000,0x00200000) IROM2(0x00200000,0x00200000) XRAM(0x2007C000,0x00004000) XRAM2(0x40024000,0x00001000) XRAM3(0x00000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: carro
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT6: ROM 0x2007c000 size 0x4000
  memory RVCT7: ROM 0x40024000 size 0x1000
  memory RVCT8: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x5c000
